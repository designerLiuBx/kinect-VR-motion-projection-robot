# Keil uVision project Template.uvprojx, settings and files
target Template (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429VI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,__FPU_USED=1,__FPU_PRESENT=1,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\liu_general;..\liu_general\INCLUDE;..\liu_general\SCHEDULER;..\liu_general\STRUCTCONFIG;..\liu_drivers;..\liu_drivers\OLED;..\liu_drivers\ADC;..\liu_drivers\I2C;..\liu_drivers\LED;..\liu_drivers\TIME;..\liu_drivers\ADS1292;..\liu_drivers\DMA;..\liu_drivers\SPI;..\liu_drivers\CONPUTERUP;..\SYSTEM\usart3;..\liu_algorithm\CONTROL_OLED;..\liu_algorithm\MOTION_COMPUTING;..\liu_drivers\KEY;..\liu_general\INIT;..\SYSTEM\usart4;..\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\CMSIS\Include;..\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\CMSIS\DSP_Lib;..\SYSTEM\usart2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../STM32F4xx_DSP_StdPeriph_Lib_V1.8.0/Libraries/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group liu_general
    ../liu_general/INIT/: All_init.c
    ../liu_general/SCHEDULER/: Gen_Scheduler.c
    ../liu_general/STRUCTCONFIG/: Gen_Structconfig.c Gen_Structconfig.h
    ../liu_general/INCLUDE/: Gen_include.h
  group liu_algorithm
    ../liu_algorithm/CONTROL_OLED/: control_oled.c
    ../liu_algorithm/MOTION_COMPUTING/: motion_comp.c
    ../liu_general/: arm_fir_f32.c arm_fir_f32.h
  group liu_drivers
    ../liu_drivers/TIME/: Drv_timer.c
    ../liu_drivers/KEY/: Drv_key.c
    ../liu_drivers/LED/: Drv_led.c
    ../liu_drivers/I2C/: Drv_i2c.c
    ../liu_drivers/OLED/: Drv_oled.c
    ../liu_drivers/ADC/: Drv_adc.c
    ../liu_drivers/SPI/: Drv_spi.c
    ../liu_drivers/ADS1292/: Drv_ADS1292.c
    ../liu_drivers/CONPUTERUP/: UpperComputer_ANO_v7.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma2d.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/usart3/: usart3_it.c
    ../SYSTEM/usart4/: usart4.c
    ../SYSTEM/usart2/: usart2.c
  group README
    ../: readme.txt
